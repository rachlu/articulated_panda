Commit message: Working on Grasping using Panda

File: models/short_floor.urdf (robot description, URDF)
Before this commit: robot flat_terrain, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1.23 1.54ccd 0.1; visual box size=1.23 1.54 0.1
